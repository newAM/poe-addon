File: w5500_eth_iface.kicad_sch (KiCad schematic)
At the start: 13 parts, among them U4 W5500, Y1 25MHz

Commit message: Add LCSC part numbers
Parts:
- U4: LCSC (none) -> C32843
